# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  group LCD1602
    ./: lcd1602.c LCD1602.h
  group motor
    ./: motor.c motor.h
  group car
    ./: main.c main.h
  group speedtest
    ../car_pwm/: speed.c motorspeed.h
